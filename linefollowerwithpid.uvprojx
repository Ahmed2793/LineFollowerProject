# Keil uVision project linefollowerwithpid.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: linefollowerwithpid
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c Clock_Config.h Delay_ms.h MYPID.c MYPID.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
